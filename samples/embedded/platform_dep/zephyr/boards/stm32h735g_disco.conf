## samples/embedded/platform_dep/zephyr/boards/stm32h735g_disco.conf
```kconfig
# STM32H735-specific configuration

CONFIG_ETH_STM32_HAL=y
CONFIG_SOPC_ALLOC_SECTION="DTCM"
```
